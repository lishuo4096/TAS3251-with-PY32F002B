# Keil uVision project TAS3251_EVM.uvprojx, settings and files
target TAS3251_EVM (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TAS3251_EVM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Bx5,USE_HAL_DRIVER
  c include: ../Core/INC;../Drivers/CMSIS/Include;../Drivers/PY32F002B_HAL_Driver/Inc;../Drivers/CMSIS/Device/PY32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Drivers/PY32F002B_HAL_Driver
    ../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_gpio.c py32f002b_hal_pwr.c py32f002b_hal_exti.c py32f002b_hal_i2c.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_adc.c py32f002b_hal.c py32f002b_hal_cortex.c
  group Application/User/Core
    ../Core/SRC/: rcc.c gpio.c py32f002b_it.c i2c.c tim.c main.c py32f002b_hal_msp.c adc.c adc_app.c ws2812_app.c tas3251_app.c
    ../Core/INC/: tas3251_app.h
    ./: unused.txt
  group Application/MDK
    ./: startup_py32f002b.s
  group Drivers/CMSIS
    ../Core/SRC/: system_py32f002b.c
